# Repository LonghornRacingElectric/LVJB

## KiCad design LVJB.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_Pad
J1: Section H1; Molex_Micro-Fit_3.0_43045-1212_2x06_P3.00mm_Vertical
J2: Section A1; Molex_Micro-Fit_3.0_43045-1212_2x06_P3.00mm_Vertical
J3: Section A2; Molex_Micro-Fit_3.0_43045-1212_2x06_P3.00mm_Vertical
J4: Section A3; Molex_Micro-Fit_3.0_43045-1212_2x06_P3.00mm_Vertical
J5: Section A4; Molex_Micro-Fit_3.0_43045-1212_2x06_P3.00mm_Vertical
J6: Section M; Molex_Micro-Fit_3.0_43045-1212_2x06_P3.00mm_Vertical
J7: Section B1; Molex_Micro-Fit_3.0_43045-1212_2x06_P3.00mm_Vertical
J8: Section B2; Molex_Micro-Fit_3.0_43045-1212_2x06_P3.00mm_Vertical
J9: Section K; Molex_Micro-Fit_3.0_43045-0612_2x03_P3.00mm_Vertical
J10: Section F; Molex_Micro-Fit_3.0_43045-0612_2x03_P3.00mm_Vertical
J11: Section E1; Molex_Micro-Fit_3.0_43045-1212_2x06_P3.00mm_Vertical
J12: Section E2; Molex_Micro-Fit_3.0_43045-1212_2x06_P3.00mm_Vertical
J13: Section E3; Molex_Micro-Fit_3.0_43045-1212_2x06_P3.00mm_Vertical
J14: Section T1A; Molex_Micro-Fit_3.0_43045-0612_2x03_P3.00mm_Vertical

Connections:
AMS LED: J2.10, J8.5
APPS Sensor 1: J4.3, J7.9
APPS Sensor 2: J4.4, J7.10
Ambient Temperature Sensor: J10.6
BSPD 35kW Test IN: J4.7, J13.10
BSPD 35kW Test RETURN: J4.8, J13.9
BSPD Current Sense: J4.2, J7.8
Driven Wheelspeed: J5.10, J14.4
Emeter CAN H: J3.10, J13.4
Emeter CAN L: J3.11, J13.5
GND: J1.1, J1.2, J3.5, J5.4, J5.11, J6.9, J6.10, J6.11, J8.6, J9.1, J12.7, J13.7, J14.3, J14.5
IMD LED: J2.9, J8.4
J1772 Pilot: J2.4, J11.10
J1772 Prox: J2.5, J11.7
LV Bypass Detect OUT: J6.12, J11.3
LV Charge Detect OUT: J6.6, J11.4
PWM Cooling: J5.7
Shutdown AE: J2.1, J11.6
Shutdown BA: J2.2, J7.2
Shutdown EB: J7.6, J11.1
Shutdown EF: J10.5, J11.2
Shutdown FA: J2.6, J10.3
TSAL Energized: J3.12, J11.9
TSAL Safe: J3.6, J11.12
TSCU Latching Reset: J2.8, J11.11
Tachometer Cooling: J5.8
Telemetry CAN H AE: J5.2, J13.8
Telemetry CAN H EB: J8.9, J13.2
Telemetry CAN H MA: J5.6, J6.2
Telemetry CAN H TM: J6.8, J14.2
Telemetry CAN L AE: J5.1, J13.3
Telemetry CAN L EB: J8.10, J13.11
Telemetry CAN L MA: J5.12, J6.1
Telemetry CAN L TM: J6.7, J14.1
Undriven Wheelspeed: J5.5, J7.12
VCU Brake 1: J4.5, J7.4, J9.3
VCU Brake NOT 2: J4.1, J7.7, J9.6
VCU CAN1 H: J3.7, J12.6
VCU CAN1 L: J3.8, J12.12
VCU CAN2 H AE: J3.2, J12.4
VCU CAN2 H EKH: J1.7, J9.4, J12.1
VCU CAN2 H HB: J1.6, J8.12
VCU CAN2 L AE: J3.1, J12.5
VCU CAN2 L EKH: J1.8, J9.5, J12.9
VCU CAN2 L HB: J1.5, J8.11
VCU CAN3 H AE: J3.3, J12.3
VCU CAN3 H EB: J8.8, J12.10
VCU CAN3 L AE: J3.4, J12.2
VCU CAN3 L EB: J8.7, J12.11
VCU CAN4 H: J2.11, J13.6
VCU CAN4 L: J2.7, J13.1
VCU Drive: J4.12, J8.2
VCU Manual Regen Lever: J8.1
VCU Park: J4.6, J8.3
VCU Sensor 5V: J4.9, J7.3
VCU Sensor GND: J4.10, J7.11
VCU Wake: J2.12, J12.8

Notes on the sheet:
Section B
Section M
Section A
Section F
Section T1A
Section K
Section E
Section H

Board: 2 copper layers, 125.0 x 45.0 mm, 18 parts (0 on the bottom side), 53 nets.

## Commit log

2023-01-11 Initial commit?
2023-01-15 6 pin conn added for K
2023-01-15 2mm wiring added
2023-01-15 Harness B extra conn added
2023-01-29 Fixed harness A
2023-02-05 Added the 24V pin locations and fixed other issues
2023-02-05 added art
